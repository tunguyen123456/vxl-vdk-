	ORG 0000H
MAIN:	MOV	DPTR,#MALED
	MOV	R3,#0
	MOV	R2,#3
	MOV	R1,#4
	MOV	R0,#5
	JMP	LAP2
	MOV	R3,#0
LAP00:	MOV	R2,#0	
LAP0:	MOV	R1,#0
LAP1:	MOV	R0,#0
	

LAP2:	
	
	MOV 	A,R0
	MOVC	A,@A+DPTR  
	MOV	P0,A
	
	MOV	A,R1
	MOVC	A,@A+DPTR
	MOV	P1,A

	MOV 	A,R2
	MOVC	A,@A+DPTR  
	MOV	P2,A
	
	
	MOV	A,R3
	MOVC	A,@A+DPTR
	MOV	P3,A
	
	
	
	LCALL	TRE
	CJNE	R3,#3,NHAN1
	CJNE	R2,#4,NHAN1
	CJNE	R1,#7,NHAN1
	CJNE	R0,#8,NHAN1
	LJMP	$
	
	
NHAN1:
	INC	R0
	CJNE	R0,#10,LAP2
	INC	R1
	CJNE	R1,#10,LAP1
	INC	R2
	CJNE	R2,#10,LAP0
	INC	R3
	CJNE	R3,#10,LAP00
	JMP	MAIN
	
TRE:	MOV	R5,#10
TRE13:	MOV	R6,#10
TRE14:	MOV	R7,#10
TRE15:	DJNZ	R7,TRE15
	DJNZ	R6,TRE14
	DJNZ	R5,TRE13
	
RET
MALED:
	DB	0C0H,0F9H,0A4H,0B0H,99H,92H,82H,0F8H,80H,90H

END