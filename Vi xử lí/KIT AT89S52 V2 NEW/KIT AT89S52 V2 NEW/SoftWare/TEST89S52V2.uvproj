# Keil uVision project TEST89S52V2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: TEST89S52V2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\TESTKIT89S52V2;.\Device\Include;.\Main\Include;.\ProjectLib\Include
  group Main
    ./: STARTUP.A51
    ./Main/Source/: main.c
  group Device
    ./Device/Source/: delay.c lcd1602.c uart.c ds18b20.c timer.c
  group Projectlib
    ./ProjectLib/Source/: Control.c
